options:
  parameters:
    generate_options: qt_gui
    id: GNUTest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\jonne\OneDrive\Documents\University\Master\P5\RADAR\radar_project\COTS\audacity_recordings\SDR_CW_MULTIPLE_REAL.wav
    format: FORMAT_WAV
    samp_rate: '44100'
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\jonne\OneDrive\Documents\University\Master\P5\RADAR\radar_project\COTS\audacity_recordings\SDR_CW_MULTIPLE_IMAG.wav
    format: FORMAT_WAV
    samp_rate: '44100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '5800000000'
    fftsize: '1024'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '5800000000'
    gain0: '60'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '5800000000'
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
